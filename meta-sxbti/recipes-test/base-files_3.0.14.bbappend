FILESEXTRAPATHS := "${THISDIR}/${PN}:"

dirs755 += "/media/sda1 \
            /media/sda2 \
            /media/sda3 \
            /media/sda4 \
            /media/sda5 \
            /media/sda6 \
            /media/mmcblk0p1 \
            /media/mmcblk0p2 \
            /media/mmcblk0p3 \
            /media/mmcblk0p4 \      
            "
